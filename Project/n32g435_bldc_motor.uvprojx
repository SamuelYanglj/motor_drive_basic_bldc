# Keil uVision project n32g435_bldc_motor.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::.\ARMCompiler-505_b106)
  device: N32G435RB Nationstech
  pack: Nationstech.N32G43x_DFP.0.9.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: n32g435_bldc_motor
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\Lib\inc;..\Libraries\Lib\src;..\Libraries\Startup;..\Libraries\SysConfig;..\Libraries\SysCore;..\Source\App;..\Source\Bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../Libraries/Startup/: startup_n32g43x.s
  group System_Config
    ../Libraries/SysConfig/: system_n32g43x.c
  group Syetem_Stdlib
    ../Libraries/Lib/src/: misc.c n32g43x_adc.c n32g43x_can.c n32g43x_comp.c n32g43x_dac.c n32g43x_dma.c n32g43x_exti.c n32g43x_flash.c n32g43x_gpio.c n32g43x_opamp.c n32g43x_rcc.c n32g43x_spi.c n32g43x_tim.c n32g43x_usart.c
  group Bsp
    ../Source/Bsp/: bsp_header.h n32g43x_it.c bsp_io.c bsp_systick.c bsp_key.c bsp_led.c bsp_uart.c bsp_uart_cb.c bsp_pwm.c bsp_pwm_cb.c
  group App
    ../Source/App/: app_header.h main.c
  group ReadMe
    ../ReadMe/: ReadMe.txt
